# Keil uVision project motor_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: motor_test +hex
  c flags: SizeSpeed=1
  c include: ..\App;..\Common;..\Driver;..\Mid;..\Utilities
  group startup
    ./: STARTUP.A51
  group App
    ../App/: main.c irfapp_main.c irfapp_main.h main_func.c main_func.h main_init.c main_init.h
  group Mid
    ../Mid/: floor.c floor.h irf.c irf.h motor.c motor.h relay.c relay.h
  group Driver
    ../Driver/: adc.c adc.h delay.c delay.h pwm.c pwm.h uart.c uart.h gpio.c gpio.h timer.c timer.h tick.c tick.h flash.c flash.h
  group Utilities
    ../Utilities/: queue.c queue.h xor.c xor.h
  group Common
    ../Common/: Function_Define.h N76E003.h SFR_Macro.h
